Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-12-20T04:48:10
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: AM-80041-W-W40
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Amos 3 Recessed downlights
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour Temperature 3000K ,4000K - Eco-friendly LED product for energy saving and visual consistency. - Modular design for easy maintenance with future proofing. - Propriety lens design for high LOR. - Reliable thermal management for long life and lumen maintenance. - Dimming options available. - Excellent CRI for actual colour reproduction. - White powder coated aluminium reflector - Die-cast aluminium / White or black coated - Die-cast aluminium heat sink / Excellent thermal Management.; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Amos, Recessed downlights; Housing color: White, Black, Silver
General Information - Weight: 1.59 kg; Case height: 21.8 cm; Case diameter: 17 cm; Article name: Amos 3 Recessed downlights; Uld creation date: 20.12.2019 03:48:10
Mounting Information - Mounting height: 180 cm
Photometric Information - Light output ratio: 0.999896; Luminous flux: 2491.25 lm; Lamp names: AM-80041-W-W40
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 30.3 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 30.3 W; LightFixtureMountingType: Recessed; LightFixturePlacingType: Ceiling; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 2491.25 lm; LightEmitterNominalPower: 30.3 W; Spectrum: 380: 0.012934, 385: 0.01155, 390: 0.011614, 395: 0.010494, 400: 0.010484, 405: 0.010279, 410: 0.00968, 415: 0.011352, 420: 0.017493, 425: 0.049381, 430: 0.110001, 435: 0.213323, 440: 0.422394, 445: 0.673726, 450: 0.939462, 455: 0.97829, 460: 0.851938, 465: 0.670014, 470: 0.549521, 475: 0.442322, 480: 0.39367, 485: 0.37832, 490: 0.392506, 495: 0.423255, 500: 0.468951, 505: 0.509823, 510: 0.551923, 515: 0.57673, 520: 0.59894, 525: 0.611155, 530: 0.623829, 535: 0.629598, 540: 0.636475, 545: 0.645361, 550: 0.655589, 555: 0.671682, 560: 0.690295, 565: 0.709359, 570: 0.730587, 575: 0.748998, 580: 0.767832, 585: 0.786295, 590: 0.801043, 595: 0.812518, 600: 0.821303, 605: 0.827334, 610: 0.827494, 615: 0.819016, 616: 0.814072, 617: 0.810179, 618: 0.806287, 619: 0.802012, 620: 0.797737, 625: 0.764787, 630: 0.724964, 635: 0.680899, 640: 0.638133, 645: 0.594845, 650: 0.555125, 655: 0.51894, 660: 0.486181, 665: 0.454614, 670: 0.422297, 675: 0.388355, 680: 0.352992, 685: 0.318193, 690: 0.282697, 695: 0.245701, 700: 0.215906, 705: 0.189853, 710: 0.163229, 715: 0.14476, 720: 0.12737, 725: 0.114158, 730: 0.097674, 735: 0.085444, 740: 0.075708, 745: 0.068751, 750: 0.061453, 755: 0.056451, 760: 0.052251; ColorTemperature: 4032 K; ColorRenderingIndex: 80; ColorAppearance: 4032 K
